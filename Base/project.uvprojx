# Keil uVision project project.uvprojx, settings and files
target Register (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: "E:\Software\Keil MDK\ARM\arm5_compiler\bin\fromelf.exe" --bin -o "!L.bin" "!L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: .\Start;.\User;.\Hardware\LED;.\Hardware\KEY;.\Hardware\OLED;.\Hardware\USART;.\Hardware\IIC;.\Hardware\TIM;.\Hardware\DMA;.\Hardware\ADC;.\Hardware\SPI;.\Hardware\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c Delay.c Timer.c
  group Hardware/LED
    ./Hardware/LED/: led.c led.h
  group Hardware/KEY
    ./Hardware/KEY/: key.c key.h
  group Hardware/OLED
    ./Hardware/OLED/: Font.c Font.h oled.c oled.h
  group Hardware/USART
    ./Hardware/USART/: usart.c usart.h
  group Hardware/IIC
    ./Hardware/IIC/: HardI2C.c HardI2C.h SoftI2C.c SoftI2C.h
  group Hardware/TIM
    ./Hardware/TIM/: tim1.c tim3.c HCSR04.c MHSS.c
  group Hardware/DMA
    ./Hardware/DMA/: dma.c dma.h
  group Hardware/ADC
    ./Hardware/ADC/: adc_dma.c adc.c
  group Hardware/SPI
    ./Hardware/SPI/: softSPI.c hardSPI.c w25q64.c w25q64.h w25q64_ins.h
